# Keil uVision project music.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: music +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../示例工程/八位数码管滚动显示工程（BSP版本）/八位数码管滚动显示工程/八位数码管滚动显示_BSP版/source/: STCBSP_V3.6.LIB
